# Keil uVision project STM32_RTT_F107RC.uvproj, settings and files
target STM32_RTT_F107RC (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32_RTT_F107RC +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\Target\ecu-r-m3.bin ..\build\STM32_RTT_F107RC.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\..\ECU-R;..\components\CMSIS\Include;..\components\dfs;..\components\dfs\include;..\components\DeviceDrivers;..\components\finsh;..\components\net\lwip-1.4.1\src;..\components\net\lwip-1.4.1\src\arch\include;..\components\net\lwip-1.4.1\src\include;..\components\net\lwip-1.4.1\src\include\ipv4;..\components\net\lwip-1.4.1\src\netif;..\rtt\include;..\libcpu\arm\common;..\libcpu\arm\cortex-m3;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\applications;..\drivers;..\ECU\main\inc;..\Test\inc;..\ECU\NTP\inc;..\components\net\ethernet;..\components\net\WIFI;..\applications;..\components\armlibc;..\ECU\client\inc;..\components\FTP;..\ECU\control_client\inc;..\ECU\Update\inc;..\ECU\IDWriter\inc;..\ECU\NTP\inc;..\ECU\ECUDBG\inc;..\ECU\PhoneServer\inc;..\ECU\DRMConnect\inc
  memory RVCT4: ROM 0x8008000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    ../applications/: application.c startup.c threadlist.c
  group Drivers
    ../drivers/: board.c completion.c dataqueue.c platform.c stm32f10x_it.c usart.c serial.c ds1302z_rtc.c led.c Flash_24L512.c key.c rt_stm32f10x_spi.c lan8720rst.c cpuusage.c mcp1316.c
    ../components/DeviceDrivers/: 485usart.c
  group STM32_StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_spi.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Kernel
    ../rtt/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c udelay.c
  group CORTEX-M3
    ../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../components/DeviceDrivers/: rtc.c spi_core.c spi_dev.c spi_flash_w25qxx.c watchdog.c timer.c usart5.c powerIO.c
    ../components/net/ethernet/: stm32_eth.c
  group finish
    ../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group LwIP
    ../components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group FileSystem
    ../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../components/dfs/filesystems/elmfat/: ff.c dfs_elm.c
  group LIBC
    ../components/armlibc/: libc_syms.c mem_std.c stubs.c
  group ECU_MAIN
    ../ECU/main/src/: bind_inverters.c channel.c checkdata.c datetime.c ema_control.c file.c main-thread.c protocol.c resolve.c zigbee.c setpower.c set_ird.c clear_gfdi.c turn_on_off.c set_protection_parameters.c set_protection_parameters_inverter.c remote_update.c crc.c
  group FTP
    ../components/FTP/: thftpapi.c
  group ECU_CONTROL_CLIENT
    ../ECU/control_client/src/: control_client.c myfile.c mysocket.c remote_control_protocol.c inverter_id.c comm_config.c inverter_maxpower.c inverter_onoff.c inverter_gfdi.c ecu_flag.c inverter_ird.c inverter_update.c inverter_ac_protection.c custom_command.c mycommand.c power_factor.c
  group ECU_CLIENT
    ../ECU/client/src/: client.c clientSocket.c datelist.c
  group TEST
    ../Test/src/: listdir.c readspeed.c readwrite.c seekdir.c tcpClient.c tcpServer.c writespeed.c
  group Update
    ../ECU/Update/src/: flash_if.c remoteUpdate.c
  group IDWriter
    ../ECU/IDWriter/src/: idwriter.c
  group NTPApp
    ../ECU/NTP/src/: ntpapp.c ntpcomm.c
  group ECUDBG
    ../ECU/ECUDBG/src/: debug.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group PhoneServer
    ../ECU/PhoneServer/src/: phoneServer.c wifi_comm.c
  group DRM_connect
    ../ECU/DRMConnect/src/: DRMConnect.c
